# Keil uVision project TivaC_Blink_FWD.uvprojx, settings and files
target TM4C123GH6PM (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TivaC_Blink_FWD
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\Src\App;.\Src\Common;.\Src\Config;.\Src\MCAL\DioDriver;.\Src\MCAL\GptDrivier;.\Src\MCAL\PortDriver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./Src/App/: main.c
  group Common
    ./Src/Common/: systick.c systick.h tm4c123gh9pm_HW.h Std_Types.h
  group MCAL
    ./Src/MCAL/DioDriver/: dio.c dio.h
    ./Src/MCAL/GptDrivier/: timer.c timer.h
    ./Src/MCAL/PortDriver/: port.c port.h
  group Config
    ./Src/Config/: Port_Cfg.h Port_Lcfg.c Timer_Cfg.h Timer_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
